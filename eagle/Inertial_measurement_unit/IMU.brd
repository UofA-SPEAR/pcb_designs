# Repository UofA-SPEAR/pcb_designs (continued)

## EAGLE design drive_controller/DriveControllerBoard.brd

Board: 2 copper layers, 47.7 x 91.0 mm, 12 parts (0 on the bottom side), 10 nets.

Parts:
C2: 100nf; C0805
D1: CGRM4001-G; SOD-123_MINI-SMA
R3, R4, R5, R6: 10K; R0805
U$1, U$2, U$5, U$6: AMP-MTE-4MALE
U$3: STM-DEV-BOARD
U$4: AMP-MTE-2MALE

Connections:
1A: R3.1, U$2.1, U$3.PA5
1B: R4.1, U$2.2, U$3.PA6
2A: R5.1, U$1.1, U$3.PA2
2B: R6.1, U$1.2, U$3.PA3
+3V3: R3.2, R4.2, R5.2, R6.2, U$1.3, U$2.3, U$3.3.3V
+5V: C2.1, D1.A, D1.C, U$3.5V, U$5.1, U$6.1
CANH: U$3.CANH, U$5.2, U$6.2
CANL: U$3.CANL, U$5.3, U$6.3
GND: C2.2, U$1.4, U$2.4, U$3.GND, U$3.GND@2, U$3.GND@3, U$4.P$2, U$5.4, U$6.4
USART_3: U$3.PA4, U$4.P$1

## EAGLE design as5600-encoder/as5600_adapter.brd

Parts:
C1: 100nF; C0603
C2: 10uF; C0805
IC1: AS5600-ASOT; SOIC127P600X175-8N
JP1: PINHD-1X3; 1X03
JP2: JUMPER-SMT_2_NC_PASTE_NO-SILK; SMT-JUMPER_2_NC_PASTE_NO-SILK
R1: 100K; R0603

Connections:
+3V3: C1.1, C2.1, IC1.1 (VDD5V), IC1.2 (VDD3V3), JP1.3, JP2.2
GND: C1.2, C2.2, IC1.4 (GND), IC1.5 (PGO), JP1.1, R1.1
unnamed: IC1.8 (DIR), JP2.1, R1.2
OUT: IC1.3 (OUT), JP1.2

Board: 2 copper layers, 16.0 x 16.0 mm, 6 parts (2 on the bottom side), 4 nets.

## Commit log (part)

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2018-03-15 Initial commit.
2018-06-25 Added BOM
2018-06-26 Added some more info to README.md
2018-06-27 Add files via upload
    First ver of arm encoder
2018-06-29 Made some changes to arm position sensor. - Corrected potentiometer footprint. - Made mounting holes and overall size nice numbers (20x35 and 30x45). - Added some silkscreen features.
2018-06-29 Renamed folder from 'SPEAR arm position' to 'SPEAR-arm-position' to follow naming conventions.
2018-06-29 Added arm position info to README.
2018-07-04 Generated arm position Gerbers
2018-08-30 Deleted all the old PCBs and everything.
2018-08-30 Added kicad_libs/README.md
2018-08-30 modified README
2018-08-30 Finished layout`
2018-08-30 Added README for can termination board
2018-09-01 ~~stole~~ *borrowed* communication's hub design from ARVP.
    Thanks ARVP!
2018-09-01 Added an ignore rule for Gerber directories
2018-09-01 Fixed some potential issues with TCAN/MCP parts
2018-09-03 Added necessary projects to README
2018-09-05 Added CAN bus template.
    TODO:
    - Change meta/info.html to be better than it is.
    - Make the template icon fit properly.
2018-09-06 Added SPEAR logos
2018-09-06 Removed extraneous file
2018-09-06 Added SPEAR logo.
2018-09-16 made the CAN Bus HAT
2018-09-16 Started schematic
2018-09-16 fixed footprint mcp2562 and modify raspberry pi HAT
2018-09-16 Added new project and SPEAR library
2018-09-18 Added resistor and LED slection to parts selection doc.
2018-09-20 added MCP2515, VNH5019, fixed MCP2562
2018-09-21 Added Cree RGB LED and PCA9685 to library.
2018-09-22 Added STM32F103CB device.
2018-09-23 Started drive_pdu tutorial stuff
2018-09-26 added stm32f103cbt6 with all 3d packages
2018-09-26 added step file for raspberry pi can bus hat
2018-09-28 added step file for arm-controller with minor changes
2018-10-05 Made more progress. Schematic mostly done.
2018-10-06 Changes to PCB Design
2018-10-14 Added St link v2 connection, with some modification of step file
2018-10-15 Added various power connectors to library.
2018-10-15 Finished schematic, started layout
2018-10-15 Reviewed board design. A few changes to make.
2018-10-15 Noticed a quirk with CAN connectors in review.
2018-10-15 Fixed some footprint issues and most of positioning.
    I botched a few footprints so I had to fix them :/
2018-10-17 Finished placement.
2018-10-17 Finished a lot of routing.
    Most of the PCA9685 stuff is routed.
    Todo:
    - Add programming header.
    - Route everything else.
    - Add planes.
2018-11-10 Finished Layout.
    - Passes DRC.
2018-11-10 Fixed a few little things I noticed.
2018-11-17 Merging libraries is annoying.
2018-11-17 Fixing library merging issues
2018-11-17 Creaded battery monitor project and BOM
2018-11-17 Added Infineon PG-TO26-3-2 footprint.
2018-11-17 Started work on schematic.
2018-11-18 Added current sense.
2018-11-18 Finished schematic for F303 design block.
2018-11-22 Finished design block
2018-11-23 Mostly finished layout.
2018-11-23 Finished layout.
2018-11-23 Improved Silkscreen and finished dimensioning.
2018-11-23 Exported CAM files
2018-11-24 generated gerbers
    Also had a little whoopsie, some stuff should be in other branches
    Oh well.
2018-11-24 Changed BOM a bit
2018-11-24 Finished BOM
2018-11-25 Added dimensions
2018-11-25 Added dimensioning
2018-12-02 Created Drive PDU
2018-12-04 Updated BOM for out of stock parts
2018-12-08 Added update potentiometer board.
2018-12-09 Fixed footprint stuff and added 3d model for pot.
2018-12-14 Added dimensioning and tweaked dimensions slightly.
2018-12-15 Finished some things
2018-12-29 Made footprints for GPS and accellerometer modules.
2019-01-03 Started work on schematic for science controller.
2019-01-28 fixed raspberrypi pinout
2019-01-31 Added some descriptions + moved footprints around.
2019-01-31 Added cortex debug header.
2019-02-01 Updated battery monitor design.
    - Added cortex debug header.
    - Added voltage divider to read voltage from batteries.
    - Added 8MHz crystal oscillator
2019-02-02 Updated BOM
2019-02-11 Nearly done the schematic.
    Unless I'm wrong, all that's left is I2C output.
2019-02-28 Completed arm PDU
2019-03-05 Finished first revision of science controller board.
    Needs review!
2019-03-09 Cleaned up some files
2019-03-09 Copied BOM from the Drive
2019-03-09 Moved arm controller BOM to correct place
2019-03-09 Cleaned up files
2019-03-12 generaed gerbers for drive PDU
2019-03-12 Tweaked board dimensions
2019-03-12 Moved misplaced mount holes
2019-03-16 Added changes for arm controller
2019-03-20 made drive controller
2019-03-23 changes based on last pull request enter the commit message for your changes. Lines starting
2019-04-13 Renamed a folder
2019-05-04 Fixed some things
2019-05-04 Generated Gerbers
2019-06-02 Added a bit of info to gain
2019-07-03 Fixing errors. Still a few to be fixed.
2019-07-03 corrected layout issues.
2019-07-10 Rounded corners
2019-07-10 fixed issues with board not being in sync with schematic
2019-07-13 Added customer reference to arm BOM
2019-07-13 Simplified resistors to 1k or 10k
2019-07-16 Some more changes
2019-09-24 Added PR template
2019-09-24 Added item to PR checklist
2019-09-24 Added batt_monitor image
2019-10-19 uploaded bom, PnP, and change some board layout:
2019-10-19 completed on boarding
2019-10-19 Completed Onboarding!
2019-10-21 added jumper for MCO switch, updated design
2019-10-21 updated BOM and PnP file
2019-11-17 added arm-controller-single
2019-11-21 fixed wire stub, changes based on request
2019-11-21 fixed silkscreen
2019-11-22 fixed DRC
2019-11-23 added dev board device
2020-01-07 it is drv8701erget
2020-01-28 new published for v1.1
2020-01-28 changes for better load
2020-01-30 changed layout to fit the CAN Connector
2020-02-04 exported file, BOM and PnP file
2020-02-26 first push for comp-pdu
2020-03-01 Changed the indication board so it uses higher power LED's now
2020-03-10 fixed hole size for speedy footprint
2020-03-11 updated to new relay to commonly used songle 10A, minor changes to layout.
2020-03-17 Moved some silkscreen so they weren't on top of eachother
2020-03-19 first upload
2020-03-19 add connectors for battery monitoring, add more protection to ADC Lines
2020-04-02 first push
2020-04-02 routed everything
2020-04-05 added schematic for sub sys pdu
2020-04-05 fixed schematic, started board
2020-04-05 submitting for review
2020-04-05 renamed vias to GND and fixed drill size
2020-04-08 fixed some issues and put board name and author on board
2020-04-09 Fixed everything that needed to be fixed (hopefully)
2020-04-12 Larger CAN traces + removed useless ground
2020-04-12 got rid of useless traces
2020-04-14 got rid of some useless ground traces
2020-04-26 made the board a bit smaller and other small changes
2020-05-06 increased size of power traces and some other traces
2020-05-06 removed the word revision as suggested
2020-05-17 Exported some PDFs
2020-05-25 initial commit, board is mostly done
2020-05-25 made silkscreen look nicer
2020-05-25 Moved some stuff around
2020-05-29 generated gerbers for upcoming order for summer 2020
2020-06-05 Fixed traces, added BOM
2020-06-06 Fixing bom
2020-06-06 made a few changes to BOM
2020-06-16 added minh's revisions to pdu
2020-11-16 new design to fix a bunch of problems
2021-03-07 Clean up some old arm controller designs
2022-09-18 Cleanup
    Moving unused stuff to an archive
2022-10-03 more cleanup
2022-10-23 moved some more stuff out of archive
2022-10-23 removed duplicate
2023-06-26 Add footprints for CAN connector and screwless terminal block
2023-06-26 Create breakout board for SPEEDYs
2023-06-28 speedy-breakout: Complete Rev 1.0 Schematics/Layout
2023-06-30 speedy-breakout: Add headers for feedback expansion
    This consists of a footprint for an arbitrary 2.54 mm connector, with
    traces to another header which can be used to easily solder wires to
    make arbitrary connections to the Speedy breakout through-holes
    depending on the desired application. A 6 pin footprint was used which
    should give enough for power + ground and up to a full 4 pin SPI
    interface. Pin 6 is tied to ground.
2023-10-29 speedy-breakout: Add generated outputs
    This adds the generated gerber outputs, 3D CAD models,
    and schematic PDF for quick reference and use.
2023-10-29 speedy-breakout: Add README
    This contains some basic info about what this board is for, as well as
    notes about the initial V1.0 design.
2023-11-26 eagle: Remove Inertial_measurement_unit
    We no longer use eagle and anything here that we need should have
    already been imported into KiCad. This commit can easily be reverted
    if we need this project.
2023-11-26 eagle: Remove arm-controller-stm32f303cct6
    We no longer use eagle and anything here that we need should have
    already been imported into KiCad. This commit can easily be reverted
    if we need this project.
2023-11-26 eagle: Remove as5600-encoder
    We no longer use eagle and anything here that we need should have
    already been imported into KiCad. This commit can easily be reverted
    if we need this project.
2023-11-26 eagle: Remove communication-hub
    We no longer use eagle and anything here that we need should have
    already been imported into KiCad. This commit can easily be reverted
    if we need this project.
2023-11-26 eagle: Remove comp-pdu
    We no longer use eagle and anything here that we need should have
    already been imported into KiCad. This commit can easily be reverted
    if we need this project.
2023-11-26 eagle: Remove spear-dev-board
    We no longer use eagle and anything here that we need should have
    already been imported into KiCad. This commit can easily be reverted
    if we need this project.
2023-11-26 eagle: Remove sub_sys_pdu
    We no longer use eagle and anything here that we need should have
    already been imported into KiCad. This commit can easily be reverted
    if we need this project.
2023-11-26 eagle: Remove eagle_libs
    We no longer use eagle and anything here that we need should have
    already been imported into KiCad. This commit can easily be reverted
    if we need this project.
2023-11-26 archive: Remove arm-controller
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
2023-11-26 archive: Remove arm_pdu
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
2023-11-26 archive: Remove battery_monitor
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
2023-11-26 archive: Remove can_termination
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
2023-11-26 archive: Remove design_blocks
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
2023-11-26 archive: Remove drive_controller
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
2023-11-26 archive: Remove drive_pdu
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
2023-11-26 archive: Remove main-pdu
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
2023-11-26 archive: Remove science_controller
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
