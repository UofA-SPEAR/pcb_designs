# Repository UofA-SPEAR/pcb_designs

File README.md:

# SPEAR PCB Designs #

Central repository to hold PCB designs for SPEAR.

All board documentation shall be held in the [Wiki.](https://github.com/UofA-SPEAR/pcb_designs/wiki/).

## Onboarding

If you plan on contributing to the PCB designs, first, you need to go through this list:

1. Sign up for github, and fill out the new member form (contact the current team lead for this).
2. Follow the [GitHub Guides](https://guides.github.com/), specifically:
  - "Hello World"
  - "Understanding the GitHub flow."
  - "Documenting your projects on GitHub"
3. Follow the [Onboarding Task](https://github.com/UofA-SPEAR/pcb_designs/wiki/Onboarding-Task).

## Contributing

In order to start a new project, there are a few steps.

1. Create a new branch for your project.
2. Create a folder for your project, with the name of your project.
3. Create an Eagle library for your project.
4. Begin a documentation page on the wiki.

### Branches

Branches are a useful concept in Git, where you can work on your portion
of the project seperately from everyone else, and then "merge" your changes back in.

We make use of branches extensively. For every project, or new task, make a new branch, with
the naming scheme `project-name-yourname`, where "yourname" is ideally your first name, or at least
something that uniquely identifies you.

When you are finished your design, make a pull request to master, and assign the team
lead to review it. This is where the team lead will do a design review and ask to make
any required changes. Once these changes are made (or there are no changes), this code will be pulled into
the main repository, and the branch will be deleted.

## EAGLE design eagle/Inertial_measurement_unit/IMU.brd

Parts:
C1, C4: 100n; C0805
C2: 120n; C0805
C3: 6.8n; C0805
C5, C6: 22p; C0805
IC1: BNO055
JP1: PINHD-1X4; 1X04
JP2: PINHD-2X20; 2X20
R1, R2, R3, R4, R5, R6, R7: 10K; R0805
Y1: ECS-.327-12.5-39-TR

Connections:
+3V3: C1.1, C2.1, C3.1, IC1.3 (VDD), IC1.28 (VDDIO), JP2.1, R1.2, R2.2, R3.2, R4.2
ADD_SEL: IC1.17 (COM3), R5.2
CAP: C4.1, IC1.9 (CAP)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, IC1.2 (GND), IC1.15 (PIN15), IC1.16 (PIN16), IC1.18 (COM2), IC1.25 (GNDIO), JP2.6, JP2.9, JP2.14, JP2.20, JP2.25, JP2.30, JP2.39, R5.1, R6.2, R7.2
INT: IC1.14 (INT), JP2.16
NBOOT: IC1.4 (NBOOT_LOAD_PIN), R2.1
NRESET: IC1.11 (NRESET), JP2.32, R4.1
PS0: IC1.6 (PS0), R7.1
PS1: IC1.5 (PS1), R6.1
SCL: IC1.19 (COM1), JP2.5, R1.1
SDA: IC1.20 (COM0), JP2.3, R3.1
UART_CTS: JP1.4, JP2.36
UART_RTS: JP1.3, JP2.11
UART_RX: JP1.2, JP2.10
UART_TX: JP1.1, JP2.8
XIN: C5.2, IC1.27 (XIN32), Y1.1
XOUT: C6.2, IC1.26 (XOUT32), Y1.2

Notes on the sheet:
IMU decoupling

Board: 2 copper layers, 21.3 x 53.7 mm, 17 parts (0 on the bottom side), 17 nets.

## EAGLE design eagle/comp-pdu/boost module.brd

Parts:
C1, C2, C3, C4, C5, C6, C9, C10: 10uF; C1206
C7: 1nF; C0603
C8: 100nF; C0603
D1: DIODE-DO-214AC; DO-214AC
IC1: ACS712ELCTR-20A-T; SOIC127P600X175-8N
JP1: PINHD-1X6; 1X06
JP3: PINHD-1X4; 1X04
LED1: LEDCHIPLED_0805; CHIPLED_0805
R1: 390k; R0603
R2, R4, R5: 10k; R0603
R3: 7.5k; R0603
U1: MT3608; SOT95P280X145-6N
U$1: 22UH-1040-5A

Connections:
+5V: C8.1, IC1.8 (VCC), JP1.3
AIOUT: JP1.1, R3.2, R4.1
EN: JP1.2, U1.4 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, IC1.5 (GND), JP1.4, JP3.1, JP3.2, LED1.C, R2.1, R4.2, U1.2 (GND)
unnamed: LED1.A, R5.1
unnamed: D1.A, U1.1 (SW), U$1.P$2 (2)
unnamed: C7.1, IC1.6 (FILTER)
unnamed: R1.1, R2.2, U1.3 (FB)
SW: C4.1, C9.1, D1.C, IC1.3 (IP-), IC1.4 (IP-_1), R1.2
VIN: C1.1, C2.1, C3.1, JP1.5, JP1.6, U1.5 (IN), U$1.P$1 (1)
VIOUT: IC1.7 (VIOUT), R3.1
VOUT: C5.1, C6.1, C10.1, IC1.1 (IP+), IC1.2 (IP+_1), JP3.3, JP3.4, R5.2

Board: 2 copper layers, 25.0 x 25.0 mm, 22 parts (0 on the bottom side), 12 nets.

## EAGLE design spear-dev-board/SPEEDY_BAREBONE/speedy barebone.brd

Parts:
C1, C2: 10uF; C0805
C3, C7, C10, C14, C15, C16, C17: 100nF; C0603
C4, C5: 22pF; C0603
IC2: STM32F103C8T6; QFP50P900X900X160-48N
JP1, JP2: PINHD-1X20; 1X20
JP3: PINHD-1X6; 1X06
LED2: LEDCHIP-LED0805; CHIP-LED0805
R1: 100k; R0603
R8: 10k; R0603
R10: 1k; R0603
U1: 3.3V; SOT23-5
U$1: MCP2562-E/SN; SOIC8
U$2: 4.2X3.25-TACTILE-SWITCH; 4.2X3.25
X1: 8MHz; NX5032

Connections:
3.3V: C2.1, C3.1, C14.1, C15.1, C16.1, C17.1, IC2.9 (VDDA), IC2.24 (VDD_1), IC2.36 (VDD_2), IC2.48 (VDD_3), JP1.1, JP2.3, JP3.6, R8.2, R10.1, U1.5 (OUT), U$1.5 (VIO)
5V: C1.1, C7.1, JP1.3, U1.1 (IN), U1.3 (EN), U$1.3 (VDD)
BOOT0: IC2.44 (BOOT0), R1.1
CANH: JP1.12, U$1.7 (CANH)
CANL: JP1.13, U$1.6 (CANL)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C10.2, C14.2, C15.2, C16.2, C17.2, IC2.8 (VSSA), IC2.23 (VSS_1), IC2.35 (VSS_2), IC2.47 (VSS_3), JP1.2, JP2.1, JP2.2, JP3.4, R1.2, U1.2 (GND), U$1.2 (VSS), U$1.8 (STBY), U$2.P$3 (3), U$2.P$4 (4)
unnamed: LED2.A, R10.2
NRST: C10.1, IC2.7 (NRST), JP2.4, JP3.2, R8.1, U$2.P$1 (1), U$2.P$2 (2)
OSC32_IN: IC2.3 (PC14-OSC32_IN), JP2.18
OSC32_OUT: IC2.4 (PC15-OSC32_OUT), JP2.17
OSC_IN: C4.1, IC2.5 (PD0-OSC_IN), X1.P$1
OSC_OUT: C5.1, IC2.6 (PD1-OSC_OUT), X1.P$2
PA0-WKUP: IC2.10 (PA0-WKUP), JP2.16
PA1: IC2.11 (PA1), JP2.15
PA2: IC2.12 (PA2), JP2.14
PA3: IC2.13 (PA3), JP2.13
PA4: IC2.14 (PA4), JP2.12
PA5: IC2.15 (PA5), JP2.11
PA6: IC2.16 (PA6), JP2.10
PA7: IC2.17 (PA7), JP2.9
PA8: IC2.29 (PA8), JP1.16
PA9: IC2.30 (PA9), JP1.15
PA10: IC2.31 (PA10), JP1.14
PA11: IC2.32 (PA11), U$1.4 (RXD)
PA12: IC2.33 (PA12), U$1.1 (TXD)
PA15: IC2.38 (PA15), JP1.11
PB0: IC2.18 (PB0), JP2.8
PB1: IC2.19 (PB1), JP2.7
PB2: IC2.20 (PB2), JP2.19
PB3_SWO: IC2.39 (PB3), JP1.10
PB4: IC2.40 (PB4), JP1.9
PB5: IC2.41 (PB5), JP1.8
PB6: IC2.42 (PB6), JP1.7
PB7: IC2.43 (PB7), JP1.6
PB8: IC2.45 (PB8), JP1.5
PB9: IC2.46 (PB9), JP1.4
PB10: IC2.21 (PB10), JP2.6
PB11: IC2.22 (PB11), JP2.5
PB12: IC2.25 (PB12), JP1.20
PB13: IC2.26 (PB13), JP1.19
PB14: IC2.27 (PB14), JP1.18
PB15: IC2.28 (PB15), JP1.17
PC13: IC2.2 (PC13-TAMPER-RTC), LED2.C
SWCLK: IC2.37 (PA14), JP3.5
SWDIO: IC2.34 (PA13), JP3.3
VBAT: IC2.1 (VBAT), JP2.20

Notes on the sheet:
MAIN MCU
PINOUT
POWER REGULATOR
Compatible MCU: * STM32F303CC * STM32F303CB * STM32F103CB * STM32F103C8 * STM32L151C8 * STM32F072C8
1.0
CAN BUS

Board: 2 copper layers, 51.2 x 23.0 mm, 23 parts (0 on the bottom side), 46 nets.

## EAGLE design can_indication/indication.brd

Parts:
C1: 100nf; C1206
C2, C4: 10uF; C1206
C3, C5: 100nF; C0805
C9, C10, C11, C12, C13, C14: 10n; C0805
D1: CGRM4001-G; SOD-123_MINI-SMA
IC1, IC2: TPS92630QPWPRQ1; SOP65P640X120-17N
J1: CONN_025MM; SCREWTERMINAL-5MM-2
R1, R3: 100; R0805
R2, R10: 2.5k; R0805
SV1, SV2: MA04-1
U$1: STM-DEV-BOARD
U$3, U$5: R50RGB-4-0045

Connections:
5V: C1.1, D1.C, U$1.5V
+3V3: U$1.3.3V, U$1.VBAT
CANH: SV1.3, SV2.3, U$1.CANH
CANL: SV1.2, SV2.2, U$1.CANL
EN1: IC1.2 (EN), U$1.PA2
EN2: IC2.2 (EN), U$1.PA3
FAULT1: IC1.6 (FAULT), U$1.PB10
FAULT2: IC2.6 (FAULT), U$1.PA4
FAULTS1: IC1.7 (FAULT_S), U$1.PB11
FAULTS2: IC2.7 (FAULT_S), U$1.PA5
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, IC1.10 (REF), IC1.17 (EP), IC2.10 (REF), IC2.17 (EP), J1.1, R1.1, R2.1, R3.1, R10.1, SV1.1, SV2.1, U$1.GND, U$1.GND@2 (GND), U$1.GND@3 (GND), U$3.P$2 (C), U$5.P$2 (C)
L1OUT1: C9.1, IC1.11 (VSNS1), IC1.16 (IOUT1), U$3.P$3 (BLU)
L1OUT2: C10.1, IC1.12 (VSNS2), IC1.15 (IOUT2), U$3.P$4 (RED)
L1OUT3: C11.1, IC1.13 (VSNS3), IC1.14 (IOUT3), U$3.P$1 (GRN)
L2OUT1: C12.1, IC2.11 (VSNS1), IC2.16 (IOUT1), U$5.P$3 (BLU)
L2OUT2: C13.1, IC2.12 (VSNS2), IC2.15 (IOUT2), U$5.P$4 (RED)
L2OUT3: C14.1, IC2.13 (VSNS3), IC2.14 (IOUT3), U$5.P$1 (GRN)
unnamed: IC1.9 (GND), R10.2
unnamed: IC2.8 (TEMP), R3.2
unnamed: IC2.9 (GND), R2.2
unnamed: D1.A, SV1.4, SV2.4
unnamed: IC1.8 (TEMP), R1.2
TIM3_CH1: IC2.3 (PWM1), U$1.PA6
TIM3_CH2: IC2.4 (PWM2), U$1.PA7
TIM3_CH3: IC2.5 (PWM3), U$1.PB0
TIM4_CH1: IC1.3 (PWM1), U$1.PB6
TIM4_CH2: IC1.4 (PWM2), U$1.PB7
TIM4_CH3: IC1.5 (PWM3), U$1.PB8
VIN: C2.1, C3.1, C4.1, C5.1, IC1.1 (VIN), IC2.1 (VIN), J1.2

Notes on the sheet:
Pin 26

Board: 2 copper layers, 70.8 x 59.7 mm, 24 parts (0 on the bottom side), 29 nets.

## EAGLE design main-pdu/Main PDU.brd

Board: 2 copper layers, 100.0 x 96.0 mm, 43 parts (0 on the bottom side), 25 nets.

Parts:
C1, C4: 100nF; C0805
C2, C5, C7, C8, C9, C10, C11: 680uF; E5-10,5
C3, C6: 10uF; C1206
D1, D2: SOD-123
J1, J2: VCF4-1000; TE_VCF4-1000
JP1: 1X04
PS1, PS2: PLM74700QDBVTQ1; SOT95P280X145-6N
R1, R2, R3, R6, R7, R8: 200k; R0805
R4, R5, R9, R10: 100k; R0805
SWITCH: 1X01
U1, U2, U3, U4, U5, U6: 3568
U$1, U$2: MOSFET-NCHD2PAK; MBRB41H100CTT4G
U$3, U$4, U$6, U$7, U$8, U$10: XT60

Connections:
GND: C2.-, C3.2, C5.-, C6.2, C7.-, C8.-, C9.-, C10.-, C11.-, D1.A, D2.A, J1.85, J2.85, JP1.2, JP1.3, PS1.2, PS2.2, R5.1, R10.1, U$3.-, U$4.-, U$6.-, U$7.-, U$8.-, U$10.-
unnamed: PS1.5, U$1.1
unnamed: C1.2, PS1.1
unnamed: R1.1, R2.2
unnamed: R2.1, R3.2
unnamed: C4.2, PS2.1
unnamed: PS2.5, U$2.1
unnamed: R3.1, R4.2
unnamed: R6.1, R7.2
unnamed: R7.1, R8.2
unnamed: R8.1, R9.2
unnamed: U1.1, U1.2, U$8.+
unnamed: U6.1, U6.2, U$4.+
unnamed: U3.1, U3.2, U$10.+
unnamed: U2.1, U2.2, U$7.+
unnamed: U5.1, U5.2, U$3.+
unnamed: U4.1, U4.2, U$6.+
REG1: C7.+, C8.+, J1.87, U4.3, U4.4, U5.3, U5.4, U6.3, U6.4
REG2: C9.+, C10.+, J2.87, U1.3, U1.4, U2.3, U2.4, U3.3, U3.4
SWITCH: D1.C, D2.C, J1.86, J2.86, SWITCH.1
VBAT1: C1.1, C2.+, C3.1, PS1.3, PS1.6, R1.2, U$1.2
VBAT2: C4.1, C5.+, C6.1, PS2.3, PS2.6, R6.2, U$2.2
VIN: C11.+, J1.30, J2.30, PS1.4, PS2.4, U$1.3, U$2.3
VIOUT1: JP1.4, R4.1, R5.2
VIOUT2: JP1.1, R9.1, R10.2

## EAGLE design comp-pdu/Comp PDU.brd

Parts:
C1, C7, C8, C9, C10, C11, C12: 100nF; C0805
C2, C3: 10uF; C1206
C4, C5, C6: 680uF; E5-10,5
D1: DIODE-DO214AA; DO214AA
D2, D5, D6, D7, D8, D9: BAT54S; SOT23
D3: DIODEDO-1N4148; DO-1N4148
D4: DIODE-DO-214AC; DO-214AC
IC1: 788TV; TO220V
J1: POWER_JACK; POWER_JACK_PTH
J2: CONN_025MM; SCREWTERMINAL-5MM-2
JP1, JP2, JP3: PINHD-1X6; 1X06
JP4, JP5, JP6, JP7, JP8, JP9: PINHD-1X4; 1X04
JP10: PINHD-1X2; 1X02
K1: SRD-24VDC-SL-C; RELAY_SRD-05VDC-SL-C
R1, R2, R3, R7, R8: 100k; R0805
R4, R5, R6: 200k; R0805
R9, R10, R11: 1k; R0805
R12: 120; R0805
SWITCH: PINHD-1X1; 1X01
U1: 3568
U$1: STM-DEV-BOARD

Connections:
+3V3: D2.2 (C2), D5.2 (C2), D6.2 (C2), D7.2 (C2), D8.2 (C2), D9.2 (C2), U$1.3.3V, U$1.3.3V@2 (3.3V), U$1.VBAT
+5V: C1.1, C3.1, IC1.3 (VO), JP1.3, JP2.3, JP3.3, U$1.5V
AIOUT1: C10.1, D8.3 (C1A2), JP1.1, U$1.PA0_WKUP (PA0-WKUP)
AIOUT2: C11.1, D7.3 (C1A2), JP2.1, U$1.PA1
AIOUT3: C12.1, D9.3 (C1A2), JP3.1, U$1.PA2
CANH: JP8.2, JP9.2, R12.2, U$1.CANH
CANL: JP8.3, JP9.3, JP10.1, U$1.CANL
EN_1: JP1.2, R1.2, U$1.PB9
EN_2: JP2.2, R2.2, U$1.PB8
EN_3: JP3.2, R3.2, U$1.PB7
GND: C1.2, C2.2, C3.2, C4.-, C5.-, C6.-, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, D2.1 (A1), D3.A, D4.A, D5.1 (A1), D6.1 (A1), D7.1 (A1), D8.1 (A1), D9.1 (A1), IC1.2 (GND), J1.GND, J1.GNDBREAK, J2.1, JP1.4, JP2.4, JP3.4, JP4.2, JP4.3, JP5.1, JP5.2, JP6.1, JP6.2, JP7.1, JP7.2, JP8.4, JP9.4, K1.A2, R1.1, R2.1, R3.1, R8.1, U$1.GND, U$1.GND@2 (GND), U$1.GND@3 (GND)
unnamed: R4.1, R5.2
unnamed: R5.1, R6.2
unnamed: R6.1, R7.2
unnamed: D1.C, J2.2
unnamed: D2.3 (C1A2), R7.1, R8.2, R9.1
unnamed: JP10.2, R12.1
unnamed: D3.C, K1.A1, SWITCH.1
unnamed: D6.3 (C1A2), JP4.4, R11.1
unnamed: D5.3 (C1A2), JP4.1, R10.1
VBAT: K1.COM, U1.1, U1.2
VBAT1: U1.3, U1.4
VIN: C2.1, C4.+, C5.+, C6.+, D4.C, IC1.1 (VI), JP1.5, JP1.6, JP2.5, JP2.6, JP3.5, JP3.6, K1.NO, R4.2
VIOUT: C7.1, R9.2, U$1.PA3
VIOUT1: C8.1, R11.2, U$1.PA4
VIOUT2: C9.1, R10.2, U$1.PA5
VOUT1_FIXED: J1.PWR, JP5.3, JP5.4
VOUT2_FIXED: D1.A, JP6.3, JP6.4
VOUT3_FIXED: JP7.3, JP7.4, JP8.1, JP9.1

Notes on the sheet:
POWER MODULE
RELAY+FUSE

Board: 2 copper layers, 100.0 x 70.0 mm, 50 parts (0 on the bottom side), 29 nets.

Notices in the files:
parts and their libraries:
SparkFun-Jumpers: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
