# Repository UofA-SPEAR/pcb_designs

File README.md:

# SPEAR PCB Designs #

Central repository to hold PCB designs for SPEAR.

All board documentation shall be held in the [Wiki.](https://github.com/UofA-SPEAR/pcb_designs/wiki/).

## Onboarding

If you plan on contributing to the PCB designs, first, you need to go through this list:

1. Sign up for github, and fill out the new member form (contact the current team lead for this).
2. Follow the [GitHub Guides](https://guides.github.com/), specifically:
  - "Hello World"
  - "Understanding the GitHub flow."
  - "Documenting your projects on GitHub"
3. Follow the [Onboarding Task](https://github.com/UofA-SPEAR/pcb_designs/wiki/Onboarding-Task).

## Contributing

In order to start a new project, there are a few steps.

1. Create a new branch for your project.
2. Create a folder for your project, with the name of your project.
3. Create an Eagle library for your project.
4. Begin a documentation page on the wiki.

### Branches

Branches are a useful concept in Git, where you can work on your portion
of the project seperately from everyone else, and then "merge" your changes back in.

We make use of branches extensively. For every project, or new task, make a new branch, with
the naming scheme `project-name-yourname`, where "yourname" is ideally your first name, or at least
something that uniquely identifies you.

When you are finished your design, make a pull request to master, and assign the team
lead to review it. This is where the team lead will do a design review and ask to make
any required changes. Once these changes are made (or there are no changes), this code will be pulled into
the main repository, and the branch will be deleted.

## KiCad design kicad/IO Interface/IO Interface.kicad_pcb

Parts:
J(2)1-1, J(2)2-1: CP6002P1V00-NH
J(2)1-2, J(2)2-2: 691137710002
J(4)1-1, J(4)2-1, J(4)3-1, J(4)4-1: CP-01302130
J(4)1-2, J(4)2-2, J(4)3-2, J(4)4-2: 691137710004

Connections:
unnamed: J(2)1-1.1, J(2)1-2.1
unnamed: J(2)1-1.2, J(2)1-2.2
unnamed: J(2)2-1.1, J(2)2-2.1
unnamed: J(2)2-1.2, J(2)2-2.2
unnamed: J(4)1-1.1, J(4)1-2.1
unnamed: J(4)1-1.2, J(4)1-2.2
unnamed: J(4)1-1.3, J(4)1-2.3
unnamed: J(4)1-1.4, J(4)1-2.4
unnamed: J(4)2-1.1, J(4)2-2.1
unnamed: J(4)2-1.2, J(4)2-2.2
unnamed: J(4)2-1.3, J(4)2-2.3
unnamed: J(4)2-1.4, J(4)2-2.4
unnamed: J(4)3-1.1, J(4)3-2.1
unnamed: J(4)3-1.2, J(4)3-2.2
unnamed: J(4)3-1.3, J(4)3-2.3
unnamed: J(4)3-1.4, J(4)3-2.4
unnamed: J(4)4-1.1, J(4)4-2.1
unnamed: J(4)4-1.2, J(4)4-2.2
unnamed: J(4)4-1.3, J(4)4-2.3
unnamed: J(4)4-1.4, J(4)4-2.4

Board: 2 copper layers, 49.8 x 119.8 mm, 12 parts (6 on the bottom side), 20 nets.

## KiCad design kicad/speedy-breakout/speedy-breakout.kicad_pcb

File kicad/speedy-breakout/README.md:

# Speedy Breakout
This is a basic breakout board for our Speedy Microcontroller.

Dimensions: 100 mm x 50 mm

## Features
- Passes 5V power from CAN bus to Speedy
- CAN connectors (Molex Mini-Lock)
- Optional CAN termination, enabled with a jumper
- Dedicated connectors to connect to motor drivers (Step/Direction or PWM/Direction)
- Through holes for all Speedy pins to ease post manufacture additions
- Through holes for adding 2.54 mm compatible headers for things like encoders

## Changelog
### V1.0: Initial design
#### Notes
- Pins A0-A3, used for the motor driver outputs, would typically be mapped to
  the 32-bit Timer 2 in the STM32, which we normally have used for the ChibiOS
  system timer. ChibiOS can use 16-bit timers so this can be worked around.
- Pins A2 and A3 on the Speedy are connected to the ST-Link chip for UART to
  USB functionality, and it seems like the ST-Link was pulling them high,
  interfering with motor driver operation. The UART functionality is provided
  by the [Black Magic Probe](https://black-magic.org/index.html) firmware. This
  can be worked around by reflashing the ST-Link MCU with official ST-Link
  firmware, which doesn't have the UART functionality.
- The CUI TBL009-254 screwless terminal blocks used for the motor driver
  outputs are a too small for stranded 22 AWG wire with wire ferrules.

Parts:
D1: D; D_SMA
J1, J2: Pin Socket 1x20; PinSocket_1x20_P2.54mm_Vertical
J3, J4: Molex Mini-Lock 53426; Molex_Mini-Lock_53426-0410_1x04_P2.50mm_Horizontal
J5: CUI TLB009-254; TerminalBlock_CUI_TBL009-254-02_1x04_P2.54mm_Horizontal
J6: CUI TBL009-254; TerminalBlock_CUI_TBL009-254-02_1x04_P2.54mm_Horizontal
J7: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J8, J9, J10, J11: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
R1: 120; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder

Connections:
+3.3V: J1.20, J2.3
+5V: D1.1 (K), J1.18
/CANH: J1.9, J3.2, J4.2, J7.1
/CANL: J1.8, J3.3, J4.3, R1.1
/NRST: J2.4
/OSC32_IN: J2.18
/OSC32_OUT: J2.17
/PA0: J2.16, J6.2
/PA1: J2.15, J6.1
/PA2: J2.14, J5.2
/PA3: J2.13, J5.1
/PA4: J2.12
/PA5: J2.11
/PA6: J2.10
/PA7: J2.9
/PA8: J1.5
/PA9: J1.6
/PA10: J1.7
/PA15: J1.10
/PB0: J2.8
/PB1: J2.7
/PB2: J2.19
/PB3: J1.11
/PB4: J1.12
/PB5: J1.13
/PB6: J1.14
/PB7: J1.15
/PB8: J1.16
/PB9: J1.17
/PB10: J2.6
/PB11: J2.5
/PB12: J1.1
/PB13: J1.2
/PB14: J1.3
/PB15: J1.4
/VBAT: J2.20
GND: J1.19, J2.1, J2.2, J3.4, J4.4, J8.6, J9.6, J10.6, J11.6
unnamed: D1.2 (A), J3.1, J4.1
unnamed: J7.2, R1.2
unnamed: J8.1, J10.1
unnamed: J8.2, J10.2
unnamed: J8.3, J10.3
unnamed: J8.4, J10.4
unnamed: J8.5, J10.5
unnamed: J9.1, J11.1
unnamed: J9.2, J11.2
unnamed: J9.3, J11.3
unnamed: J9.4, J11.4
unnamed: J9.5, J11.5

Notes on the sheet:
Motor 2 Direction
Motor 2 PWM/Step
Motor 1 PWM/Step
SPEEDY
CAN Termination Jumper
CAN Bus
Expansion headers
Motor driver interface
Motor 1 Direction

Board: 2 copper layers, 100.0 x 50.0 mm, 13 parts (0 on the bottom side), 21 nets.

## KiCad design kicad/spear-dev-board/SPEEDY_BARBONE/speedy barebone.kicad_pcb

Board: 2 copper layers, 51.2 x 23.0 mm, 23 parts (0 on the bottom side), 46 nets.

Parts:
C1, C2: 10uF; C0805
C3, C7, C10, C14, C15, C16, C17: 100nF; C0603
C4, C5: 22pF; C0603
IC2: STM32F103C8T6; QFP50P900X900X160-48N
JP1, JP2: 1X20
JP3: 1X06
LED2: CHIP-LED0805
R1: 100k; R0603
R8: 10k; R0603
R10: 1k; R0603
U1: 3.3V; SOT23-5
U$1: MCP2562-E/SN; SOIC8
U$2: 4.2X3.25-TACTILE-SWITCH; 4.2X3.25
X1: 8MHz; NX5032

Connections:
3.3V: C2.1, C3.1, C14.1, C15.1, C16.1, C17.1, IC2.9, IC2.24, IC2.36, IC2.48, JP1.1, JP2.3, JP3.6, R8.2, R10.1, U1.5, U$1.5
5V: C1.1, C7.1, JP1.3, U1.1, U1.3, U$1.3
BOOT0: IC2.44, R1.1
CANH: JP1.12, U$1.7
CANL: JP1.13, U$1.6
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C10.2, C14.2, C15.2, C16.2, C17.2, IC2.8, IC2.23, IC2.35, IC2.47, JP1.2, JP2.1, JP2.2, JP3.4, R1.2, U1.2, U$1.2, U$1.8, U$2.P$3, U$2.P$4
unnamed: LED2.A, R10.2
NRST: C10.1, IC2.7, JP2.4, JP3.2, R8.1, U$2.P$1, U$2.P$2
OSC32_IN: IC2.3, JP2.18
OSC32_OUT: IC2.4, JP2.17
OSC_IN: C4.1, IC2.5, X1.P$1
OSC_OUT: C5.1, IC2.6, X1.P$2
PA0-WKUP: IC2.10, JP2.16
PA1: IC2.11, JP2.15
PA2: IC2.12, JP2.14
PA3: IC2.13, JP2.13
PA4: IC2.14, JP2.12
PA5: IC2.15, JP2.11
PA6: IC2.16, JP2.10
PA7: IC2.17, JP2.9
PA8: IC2.29, JP1.16
PA9: IC2.30, JP1.15
PA10: IC2.31, JP1.14
PA11: IC2.32, U$1.4
PA12: IC2.33, U$1.1
PA15: IC2.38, JP1.11
PB0: IC2.18, JP2.8
PB1: IC2.19, JP2.7
PB2: IC2.20, JP2.19
PB3_SWO: IC2.39, JP1.10
PB4: IC2.40, JP1.9
PB5: IC2.41, JP1.8
PB6: IC2.42, JP1.7
PB7: IC2.43, JP1.6
PB8: IC2.45, JP1.5
PB9: IC2.46, JP1.4
PB10: IC2.21, JP2.6
PB11: IC2.22, JP2.5
PB12: IC2.25, JP1.20
PB13: IC2.26, JP1.19
PB14: IC2.27, JP1.18
PB15: IC2.28, JP1.17
PC13: IC2.2, LED2.C
SWCLK: IC2.37, JP3.5
SWDIO: IC2.34, JP3.3
VBAT: IC2.1, JP2.20

## KiCad design kicad/comp-pdu/buck-module/buck module 5v.kicad_pcb

Board: 2 copper layers, 25.0 x 25.0 mm, 28 parts (6 on the bottom side), 16 nets.

Parts:
C1, C2, C11, C12, C14: 100nF; C0603
C3, C4, C8, C9, C10, C15: 10uF; C1206
C5, C16: 10nF; C0603
C6: 22pF; C0603
C7: 2200pF; C0603
C13: 1nF; C0603
D1: DO214AA
IC1: TPS54531DDA; SOIC127P600X170-9N
IC2: ACS712ELCTR-20A-T; SOIC127P600X175-8N
JP1: 1X04
JP2: 1X06
R1: 37.4k; R0603
R2: 51.1; R0603
R3: 200k; R0603
R4: 39k; R0603
R5: 7.5k; R0603
R6: 10k; R0603
U$1: 10uH; 22UH-1040-5A

Connections:
+5V: C14.1, IC2.8, JP2.3
AIOUT: JP2.1, R5.1, R6.2
EN: IC1.3, JP2.2
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, D1.A, IC1.7, IC1.9, IC2.5, JP1.3, JP1.4, JP2.4, R1.1, R4.1, R6.1
unnamed: C1.2, IC1.1
unnamed: C1.1, D1.C, IC1.8, U$1.P$1
unnamed: C7.2, R1.2
unnamed: C2.1, IC1.4
unnamed: C6.1, C7.1, IC1.6
unnamed: C13.1, IC2.6
unnamed: R2.1, R3.2
unnamed: IC1.5, R3.1, R4.2
SW: C8.1, C9.1, IC2.3, IC2.4, R2.2, U$1.P$2
VIN: C3.1, C4.1, C5.1, IC1.2, JP2.5, JP2.6
VIOUT: IC2.7, R5.2
VOUT: C10.1, C11.1, C12.1, C15.1, C16.1, IC2.1, IC2.2, JP1.1, JP1.2

## KiCad design kicad/arm-controller/arm-controller-1.1/arm controller single v1.1.kicad_pcb

Board: 2 copper layers, 100.0 x 50.0 mm, 51 parts (0 on the bottom side), 51 nets.

Parts:
C1, C2, C3: 1uF; C0603
C4, C7, C8, C10, C11, C12, C13, C14, C16, C17: 100nF; C0603
C5, C6, C18: 680uF; E5-10,5
C9: 1000pF; C0603
C15: 10uF; C1206
D1: CGRM4001-G; SOD-123_MINI-SMA
IC1: NC7SZ157P6X; SOT65P210X110-6N
IC2: DRV8701PRGER; QFN50P400X400X100-25N
IC3: TS5A3357DCUT; SOP50P310X90-8N
J1, J2: 1017503
J3: 5-103669-4; TE_5-103669-4
JMP1: 0R-JUMPB; B0R-JMP
JP1, JP2: 1X04
JP3, JP4: 1X20
JP5, JP6: 1X02
LED1: CHIP-LED0805
PS1: PLM74700QDBVTQ1; SOT95P280X145-6N
R1, R2, R6, R9: 10k; R0603
R3, R7: 0.01; R2512
R4: 33k; R0603
R5: 7.5k; R0603
R8: 1k; R0603
R10: 120; R0603
U1: 4MB Flash; SO08
U$1, U$2, U$3, U$4, U$6: MOSFET-NCHDFN8-5X6; ALOM_DFN5X6_8L_EP1_P
U$5: SMS-004

Connections:
+3V3: C13.1, C16.1, C17.1, IC1.5, IC3.8, JMP1.3, JP3.3, JP3.20, JP4.1, R1.2, R2.2, R9.2, U1.3, U1.7, U1.8
+5V: C7.1, C10.1, C12.1, D1.C, JMP1.1, JP4.3
+5V/3V: J3.4, JMP1.2
CANH: JP1.3, JP2.3, JP4.12, JP6.1, R10.1
CANL: JP1.2, JP2.2, JP4.13, JP5.2, JP6.2
DAC: IC2.6, JP3.12
FAULT: IC2.9, JP4.6, R2.1
GH1: IC2.17, U$3.4
GH2: IC2.24, U$1.4
GL1: IC2.19, U$4.4
GL2: IC2.22, U$2.4
GND: C1.2, C2.2, C5.-, C6.-, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C15.2, C16.2, C17.2, C18.-, IC1.2, IC2.5, IC2.16, IC2.20, IC2.25, IC3.4, J2.1, J2.2, J3.5, JP1.1, JP2.1, JP3.1, JP3.2, JP4.2, LED1.C, PS1.2, R3.1, R4.1, R6.2, R7.1, U1.4, U$5.5, U$5.6, U$5.7, U$5.8
IDRIVE: IC2.12, R4.2
IN1: IC2.15, JP4.5
IN2: IC2.14, JP4.4
MISO: IC3.2, JP3.10, U1.2
MOSI: JP3.9, U1.5
MUX: IC3.7, J3.3
MUX2: IC1.4, J3.2
unnamed: D1.A, JP1.4, JP2.4
unnamed: LED1.A, R8.1
unnamed: PS1.5, U$6.4
unnamed: C1.1, IC2.7, R8.2
unnamed: C2.1, IC2.8
unnamed: C3.2, IC2.2
unnamed: C4.1, IC2.3
unnamed: C4.2, IC2.4
unnamed: JP5.1, R10.2
unnamed: IC2.11, R5.1
unnamed: C14.1, C15.1, J2.3, J2.4, PS1.3, PS1.6, U$6.1, U$6.2, U$6.3
unnamed: C14.2, PS1.1
NODE1: JP4.14, U$5.1
NODE2: JP4.15, U$5.2
NODE3: JP4.16, U$5.3
NODE4: JP4.17, U$5.4
PA0: IC3.3, JP3.16
PB0: IC3.6, JP3.8
PB1: IC3.5, JP3.7
PB2: IC1.6, JP3.19
PB4: IC1.3, JP4.9
PB5: IC3.1, JP4.8
PB6: J3.1, JP4.7
PB10: JP3.6, R9.1, U1.1
SCK: IC1.1, JP3.11, U1.6
SH1: IC2.18, J1.1, J1.2, U$3.1, U$3.2, U$3.3, U$4.5, U$4.6, U$4.7, U$4.8, U$4.9
SH2: IC2.23, J1.3, J1.4, U$1.1, U$1.2, U$1.3, U$2.5, U$2.6, U$2.7, U$2.8, U$2.9
SLEEP: IC2.13, JP4.11
SNSOUT: IC2.10, JP4.18, R1.1
SO: JP3.15, R5.2, R6.1
SP: C9.1, IC2.21, R3.2, R7.2, U$2.1, U$2.2, U$2.3, U$4.1, U$4.2, U$4.3
VIN: C3.1, C5.+, C6.+, C8.1, C11.1, C18.+, IC2.1, PS1.4, U$1.5, U$1.6, U$1.7, U$1.8, U$1.9, U$3.5, U$3.6, U$3.7, U$3.8, U$3.9, U$6.5, U$6.6, U$6.7, U$6.8, U$6.9

File bom_single.xlsx:

Part | Value | Device | Package | Description |  |  |  |  |  |  |  |  |  |  | TION |  |  |  |  |  | EU_ROHS_COMPLIANCE HEIGHT | LINK MA | NUF | ACTURER_NAME | MANUFACTURER_PART_NUMBER | MF MOUSER_PART_NUMBER | MOUSER_PRICE-STOCK MP NUMBER_OF_POSITIONS PACKAGE | POPULARITY PRICE PRODUCT_TYPE SF_SKU | SPICEPREFIX
C1 | 1uF | C-EUC0805 | C0805 | CAPACITOR, European symbol |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 88 | C
C2 | 1uF | C-EUC0805 | C0805 | CAPACITOR, European symbol |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 88 | C
C3 | 1uF | C-EUC0805 | C0805 | CAPACITOR, European symbol |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 88 | C
C4 | 100nF | C-EUC0805 | C0805 | CAPACITOR, European symbol |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 88 | C
C6 | 330uF/35V | CPOL-US140CLH-1010 | 140CLH-1010 | POLARIZED CAPACITOR, American |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 0 | C
C7 | 330uF/35V | CPOL-US140CLH-1010 | 140CLH-1010 | POLARIZED CAPACITOR, American |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 0 | C
C8 | 100nF | C-EUC0805 | C0805 | CAPACITOR, European symbol |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 88 | C
C9 | 1nF | C-EUC0805 | C0805 | CAPACITOR, European symbol |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 88 | C
C11 | 100nF | C-EUC0805 | C0805 | CAPACITOR, European symbol |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 88 | C
IC1 | NC7SZ157P6X | NC7SZ157P6X | SOT65P210X110-6N | NC7SZ157P6X, Multiplexer Swit |  |  |  |  |  |  |  |  |  |  | 7P6X, | M | ul | tiplex | er | Switch IC Single 2 x 1, 1.65 5.5 V, 6-Pin, SC-70, 1 | 1.1mm | ON | Se | miconductor | NC7SZ157P6X | 512-NC7SZ157P6X | https://www.mouser.com/Search/Refine.aspx?Keyword=512-NC7SZ157P6X
IC2 | DRV8701E | DRV870ERGET | QFN50P400X400X100-25N | Motor / Motion / Ignition Con |  |  |  |  |  |  |  |  |  |  | Moti | on | / | Ignit | io | n Controllers & Drivers Brushed DC Motor Gate Driver (PH/EN, | PWM Ctrl) 24-VQFN -40 to 125 1mm | Te | xas | Instruments | DRV8701PRGER | 595-DRV8701PRGER | https://www.mouser.com/Search/Refine.aspx?Keyword=595-DRV8701PRGER
IC3 | TS5A3357DCUT | TS5A3357DCUT | SOP50P310X90-8N | Single 5-Ohm SP3T Analog Swit |  |  |  |  |  |  |  |  |  |  | 5-Ohm | S | P3 | T Anal | og | Switch 5-V/3.3-V 3:1 Analog Multiplexer/Demultiplexer | 0.9mm | Te | xas | Instruments | TS5A3357DCUT | 595-TS5A3357DCUT | https://www.mouser.com/Search/Refine.aspx?Keyword=595-TS5A3357DCUT
J1 |  | CONN_025MM | SCREWTERMINAL-5MM-2 | Multi connection point. Often |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | PRT-08432
J2 |  | CONN_025MM | SCREWTERMINAL-5MM-2 | Multi connection point. Often |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | PRT-08432
J3 | 5-103669-4 | 5-103669-4 | TE_5-103669-4 | 05 MTE HDR SRST LATCH W/HLDWN |  |  |  |  |  |  |  |  |  |  | HDR | SR | ST | LATCH | W | /HLDWN | Compliant | http://www.te.com/usa-en/product-5-103669-4.html |  |  |  | TE Connectivity | 5-103669-4 5 None | None Connector
JP1 |  | MOLEX 534260510 | 1X04 | MOLEX 534260510
JP2 |  | MOLEX 534260510 | 1X04 | MOLEX 534260510
JP3 |  |  | 1X20 | PIN HEADER
JP4 |  |  | 1X20 | PIN HEADER
R1 | 10k | R-US_M0805 | M0805 | RESISTOR, American symbol
R2 | 10k | R-US_M0805 | M0805 | RESISTOR, American symbol |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 45 | R
R3 | 5.0000000000000001E-3 | R-US_WSC4527 | WSC4527 | RESISTOR, American symbol |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 45 | R
R4 | 33k | R-US_M0805 | M0805 | RESISTOR, American symbol |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 0 | R
R5 | 7.5k | R-US_M0805 | M0805 | RESISTOR, American symbol |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 45 | R
R6 | 10k | R-US_M0805 | M0805 | RESISTOR, American symbol |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 45 | R
U$1 | MOSFET-NCHDFN8-5X6 | STL90N6F7 | ALOM_DFN5X6_8L_EP1_P | N-Channel MOSFET like the IPB |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  |  | 45 | R
U$2 | MOSFET-NCHDFN8-5X6 | STL90N6F7 | ALOM_DFN5X6_8L_EP1_P | N-Channel MOSFET like the IPB
U$3 | MOSFET-NCHDFN8-5X6 | STL90N6F7 | ALOM_DFN5X6_8L_EP1_P | N-Channel MOSFET like the IPB
U$4 | MOSFET-NCHDFN8-5X6 | STL90N6F7 | ALOM_DFN5X6_8L_EP1_P | N-Channel MOSFET like the IPB
U$5 | SMS-004 | SMS-004 | SMS-004
Additional Headers |  | 920-0172-01
 |  | 920-0172-01

## KiCad design kicad/comm-hub/communication-hub.kicad_pcb

Board: 2 copper layers, 51.7 x 30.5 mm, 7 parts (1 on the bottom side), 9 nets.

Parts:
C1: 10uf; C0805
JP1, JP3: 1X04
JP2: 2X15
R2, R3: 220; R0805
U$1: MCP2562-E/SN; SOIC8

Connections:
+3V3: JP2.8, U$1.5
+5V: C1.2, JP1.1, JP2.2, JP3.1, U$1.3
CAN_H: JP1.2, JP3.2, U$1.7
CAN_L: JP1.3, JP3.3, U$1.6
CAN_RXD: JP2.5, R3.2
CAN_TXD: JP2.7, R2.2
GND: C1.1, JP1.4, JP2.10, JP2.11, JP2.21, JP3.4, U$1.2, U$1.8
unnamed: R3.1, U$1.4
unnamed: R2.1, U$1.1

## KiCad design kicad/intertial-measurment-unit/IMU.kicad_pcb

Board: 2 copper layers, 21.3 x 53.7 mm, 17 parts (0 on the bottom side), 17 nets.

Parts:
C1, C4: 100n; C0805
C2: 120n; C0805
C3: 6.8n; C0805
C5, C6: 22p; C0805
IC1: BNO055
JP1: 1X04
JP2: 2X20
R1, R2, R3, R4, R5, R6, R7: 10K; R0805
Y1: ECS-.327-12.5-39-TR

Connections:
+3V3: C1.1, C2.1, C3.1, IC1.3, IC1.28, JP2.1, R1.2, R2.2, R3.2, R4.2
ADD_SEL: IC1.17, R5.2
CAP: C4.1, IC1.9
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, IC1.2, IC1.15, IC1.16, IC1.18, IC1.25, JP2.6, JP2.9, JP2.14, JP2.20, JP2.25, JP2.30, JP2.39, R5.1, R6.2, R7.2
INT: IC1.14, JP2.16
NBOOT: IC1.4, R2.1
NRESET: IC1.11, JP2.32, R4.1
PS0: IC1.6, R7.1
PS1: IC1.5, R6.1
SCL: IC1.19, JP2.5, R1.1
SDA: IC1.20, JP2.3, R3.1
UART_CTS: JP1.4, JP2.36
UART_RTS: JP1.3, JP2.11
UART_RX: JP1.2, JP2.10
UART_TX: JP1.1, JP2.8
XIN: C5.2, IC1.27, Y1.1
XOUT: C6.2, IC1.26, Y1.2

## KiCad design kicad/hall-effect-sensor/as5600_adapter.kicad_pcb

Board: 2 copper layers, 16.0 x 16.0 mm, 6 parts (2 on the bottom side), 4 nets.

Parts:
C1: 100nF; C0603
C2: 10uF; C0805
IC1: AS5600-ASOT; SOIC127P600X175-8N
JP1: 1X03
JP2: JUMPER-SMT_2_NC_PASTE_NO-SILK; SMT-JUMPER_2_NC_PASTE_NO-SILK
R1: 100K; R0603

Connections:
+3V3: C1.1, C2.1, IC1.1, IC1.2, JP1.3, JP2.2
GND: C1.2, C2.2, IC1.4, IC1.5, JP1.1, R1.1
unnamed: IC1.8, JP2.1, R1.2
OUT: IC1.3, JP1.2

## Commit log (part)

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2018-03-15 Initial commit.
2018-06-25 Added BOM
2018-06-26 Added some more info to README.md
2018-06-27 Add files via upload
    First ver of arm encoder
2018-06-29 Made some changes to arm position sensor. - Corrected potentiometer footprint. - Made mounting holes and overall size nice numbers (20x35 and 30x45). - Added some silkscreen features.
2018-06-29 Renamed folder from 'SPEAR arm position' to 'SPEAR-arm-position' to follow naming conventions.
2018-06-29 Added arm position info to README.
2018-07-04 Generated arm position Gerbers
2018-08-30 Deleted all the old PCBs and everything.
2018-08-30 Added kicad_libs/README.md
2018-08-30 modified README
2018-08-30 Finished layout`
2018-08-30 Added README for can termination board
2018-09-01 ~~stole~~ *borrowed* communication's hub design from ARVP.
    Thanks ARVP!
2018-09-01 Added an ignore rule for Gerber directories
2018-09-01 Fixed some potential issues with TCAN/MCP parts
2018-09-03 Added necessary projects to README
2018-09-05 Added CAN bus template.
    TODO:
    - Change meta/info.html to be better than it is.
    - Make the template icon fit properly.
2018-09-06 Added SPEAR logos
2018-09-06 Removed extraneous file
2018-09-06 Added SPEAR logo.
2018-09-16 made the CAN Bus HAT
2018-09-16 Started schematic
2018-09-16 fixed footprint mcp2562 and modify raspberry pi HAT
2018-09-16 Added new project and SPEAR library
2018-09-18 Added resistor and LED slection to parts selection doc.
2018-09-20 added MCP2515, VNH5019, fixed MCP2562
2018-09-21 Added Cree RGB LED and PCA9685 to library.
2018-09-22 Added STM32F103CB device.
2018-09-23 Started drive_pdu tutorial stuff
2018-09-26 added stm32f103cbt6 with all 3d packages
2018-09-26 added step file for raspberry pi can bus hat
2018-09-28 added step file for arm-controller with minor changes
2018-10-05 Made more progress. Schematic mostly done.
2018-10-06 Changes to PCB Design
2018-10-14 Added St link v2 connection, with some modification of step file
2018-10-15 Added various power connectors to library.
2018-10-15 Finished schematic, started layout
2018-10-15 Reviewed board design. A few changes to make.
2018-10-15 Noticed a quirk with CAN connectors in review.
2018-10-15 Fixed some footprint issues and most of positioning.
    I botched a few footprints so I had to fix them :/
2018-10-17 Finished placement.
2018-10-17 Finished a lot of routing.
    Most of the PCA9685 stuff is routed.
    Todo:
    - Add programming header.
    - Route everything else.
    - Add planes.
2018-11-10 Finished Layout.
    - Passes DRC.
2018-11-10 Fixed a few little things I noticed.
2018-11-17 Merging libraries is annoying.
2018-11-17 Fixing library merging issues
2018-11-17 Creaded battery monitor project and BOM
2018-11-17 Added Infineon PG-TO26-3-2 footprint.
2018-11-17 Started work on schematic.
2018-11-18 Added current sense.
2018-11-18 Finished schematic for F303 design block.
2018-11-22 Finished design block
2018-11-23 Mostly finished layout.
2018-11-23 Finished layout.
2018-11-23 Improved Silkscreen and finished dimensioning.
2018-11-23 Exported CAM files
2018-11-24 generated gerbers
    Also had a little whoopsie, some stuff should be in other branches
    Oh well.
2018-11-24 Changed BOM a bit
2018-11-24 Finished BOM
2018-11-25 Added dimensions
2018-11-25 Added dimensioning
2018-12-02 Created Drive PDU
2018-12-04 Updated BOM for out of stock parts
2018-12-08 Added update potentiometer board.
2018-12-09 Fixed footprint stuff and added 3d model for pot.
2018-12-14 Added dimensioning and tweaked dimensions slightly.
2018-12-15 Finished some things
2018-12-29 Made footprints for GPS and accellerometer modules.
2019-01-03 Started work on schematic for science controller.
2019-01-28 fixed raspberrypi pinout
2019-01-31 Added some descriptions + moved footprints around.
2019-01-31 Added cortex debug header.
2019-02-01 Updated battery monitor design.
    - Added cortex debug header.
    - Added voltage divider to read voltage from batteries.
    - Added 8MHz crystal oscillator
2019-02-02 Updated BOM
2019-02-11 Nearly done the schematic.
    Unless I'm wrong, all that's left is I2C output.
2019-02-28 Completed arm PDU
2019-03-05 Finished first revision of science controller board.
    Needs review!
2019-03-09 Cleaned up some files
2019-03-09 Copied BOM from the Drive
2019-03-09 Moved arm controller BOM to correct place
2019-03-09 Cleaned up files
2019-03-12 generaed gerbers for drive PDU
2019-03-12 Tweaked board dimensions
2019-03-12 Moved misplaced mount holes
2019-03-16 Added changes for arm controller
2019-03-20 made drive controller
2019-03-23 changes based on last pull request enter the commit message for your changes. Lines starting
2019-04-13 Renamed a folder
2019-05-04 Fixed some things
2019-05-04 Generated Gerbers
2019-06-02 Added a bit of info to gain
2019-07-03 Fixing errors. Still a few to be fixed.
2019-07-03 corrected layout issues.
2019-07-10 Rounded corners
2019-07-10 fixed issues with board not being in sync with schematic
2019-07-13 Added customer reference to arm BOM
2019-07-13 Simplified resistors to 1k or 10k
2019-07-16 Some more changes
2019-09-24 Added PR template
2019-09-24 Added item to PR checklist
2019-09-24 Added batt_monitor image
2019-10-19 uploaded bom, PnP, and change some board layout:
2019-10-19 completed on boarding
2019-10-19 Completed Onboarding!
2019-10-21 added jumper for MCO switch, updated design
2019-10-21 updated BOM and PnP file
2019-11-17 added arm-controller-single
2019-11-21 fixed wire stub, changes based on request
2019-11-21 fixed silkscreen
2019-11-22 fixed DRC
2019-11-23 added dev board device
2020-01-07 it is drv8701erget
2020-01-28 new published for v1.1
2020-01-28 changes for better load
2020-01-30 changed layout to fit the CAN Connector
2020-02-04 exported file, BOM and PnP file
2020-02-26 first push for comp-pdu
2020-03-01 Changed the indication board so it uses higher power LED's now
2020-03-10 fixed hole size for speedy footprint
2020-03-11 updated to new relay to commonly used songle 10A, minor changes to layout.
2020-03-17 Moved some silkscreen so they weren't on top of eachother
2020-03-19 first upload
2020-03-19 add connectors for battery monitoring, add more protection to ADC Lines
2020-04-02 first push
2020-04-02 routed everything
2020-04-05 added schematic for sub sys pdu
2020-04-05 fixed schematic, started board
2020-04-05 submitting for review
2020-04-05 renamed vias to GND and fixed drill size
2020-04-08 fixed some issues and put board name and author on board
2020-04-09 Fixed everything that needed to be fixed (hopefully)
2020-04-12 Larger CAN traces + removed useless ground
2020-04-12 got rid of useless traces
2020-04-14 got rid of some useless ground traces
2020-04-26 made the board a bit smaller and other small changes
2020-05-06 increased size of power traces and some other traces
2020-05-06 removed the word revision as suggested
2020-05-17 Exported some PDFs
2020-05-25 initial commit, board is mostly done
2020-05-25 made silkscreen look nicer
2020-05-25 Moved some stuff around
2020-05-29 generated gerbers for upcoming order for summer 2020
2020-06-05 Fixed traces, added BOM
2020-06-06 Fixing bom
2020-06-06 made a few changes to BOM
2020-06-16 added minh's revisions to pdu
2020-11-16 new design to fix a bunch of problems
2021-03-07 Clean up some old arm controller designs
2022-09-18 Cleanup
    Moving unused stuff to an archive
2022-10-03 more cleanup
2022-10-23 moved some more stuff out of archive
2022-10-23 removed duplicate
2023-06-26 Add footprints for CAN connector and screwless terminal block
2023-06-26 Create breakout board for SPEEDYs
2023-06-28 speedy-breakout: Complete Rev 1.0 Schematics/Layout
2023-06-30 speedy-breakout: Add headers for feedback expansion
    This consists of a footprint for an arbitrary 2.54 mm connector, with
    traces to another header which can be used to easily solder wires to
    make arbitrary connections to the Speedy breakout through-holes
    depending on the desired application. A 6 pin footprint was used which
    should give enough for power + ground and up to a full 4 pin SPI
    interface. Pin 6 is tied to ground.
2023-10-29 speedy-breakout: Add generated outputs
    This adds the generated gerber outputs, 3D CAD models,
    and schematic PDF for quick reference and use.
2023-10-29 speedy-breakout: Add README
    This contains some basic info about what this board is for, as well as
    notes about the initial V1.0 design.
2023-11-26 eagle: Remove Inertial_measurement_unit
    We no longer use eagle and anything here that we need should have
    already been imported into KiCad. This commit can easily be reverted
    if we need this project.
2023-11-26 eagle: Remove arm-controller-stm32f303cct6
    We no longer use eagle and anything here that we need should have
    already been imported into KiCad. This commit can easily be reverted
    if we need this project.
2023-11-26 eagle: Remove as5600-encoder
    We no longer use eagle and anything here that we need should have
    already been imported into KiCad. This commit can easily be reverted
    if we need this project.
2023-11-26 eagle: Remove communication-hub
    We no longer use eagle and anything here that we need should have
    already been imported into KiCad. This commit can easily be reverted
    if we need this project.
2023-11-26 eagle: Remove comp-pdu
    We no longer use eagle and anything here that we need should have
    already been imported into KiCad. This commit can easily be reverted
    if we need this project.
2023-11-26 eagle: Remove spear-dev-board
    We no longer use eagle and anything here that we need should have
    already been imported into KiCad. This commit can easily be reverted
    if we need this project.
2023-11-26 eagle: Remove sub_sys_pdu
    We no longer use eagle and anything here that we need should have
    already been imported into KiCad. This commit can easily be reverted
    if we need this project.
2023-11-26 eagle: Remove eagle_libs
    We no longer use eagle and anything here that we need should have
    already been imported into KiCad. This commit can easily be reverted
    if we need this project.
2023-11-26 archive: Remove arm-controller
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
2023-11-26 archive: Remove arm_pdu
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
2023-11-26 archive: Remove battery_monitor
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
2023-11-26 archive: Remove can_termination
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
2023-11-26 archive: Remove design_blocks
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
2023-11-26 archive: Remove drive_controller
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
2023-11-26 archive: Remove drive_pdu
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
2023-11-26 archive: Remove main-pdu
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
2023-11-26 archive: Remove science_controller
    Git preserves the history of the repo so there isn't any need to keep
    old projects around. This commit can easily be reverted if we need to
    move it out of the archive.
